# Keil uVision project projet.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: LM3S9B92 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: projet
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: moteur.s fonctions.s main2.s
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
